Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2024-11-27T14:08:18+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.0.296 - Exporter 23.0.0.296 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:208647
In: Level 1
Type - Material: Black Cast
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connector_1_Diameter: 125 mm; Connector_2_Diameter: 125 mm; Connector_3_Diameter: 125 mm; Connector_4_Diameter: 125 mm; Connector_5_Diameter: 15 mm; Connector_6_Diameter: 15 mm; Connector_7_Diameter: 15 mm; Connector_8_Diameter: 15 mm
Type - Identity Data - Type Name: Standard
Type - Other - Category: Generic Models; Family Name: Family2
Type - Pset_ProductRequirements - Category: Generic Models
Material: Black Cast, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 1.07376 m2; Volume: 0.198055 m3
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 208632
Phasing - Phase Created: New Construction

# IfcDistributionPort (8)
Description: Flow
Name | FlowDirection
3 x Port_208647 | SOURCE
3 x Port_208647 | SOURCEANDSINK
2 x Port_208647 | SINK
